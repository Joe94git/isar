require arm-trusted-firmware.inc

LIC_FILES_CHKSUM = "file://docs/license.rst;md5=713afe122abbe07f067f939ca3c480c5"

ATF_VERSION = "v2.5.1"
ATF_BRANCH = "socfpga_${ATF_VERSION}"

SRCREV = "66602dafe0614fbf2c1354e56167ff773ff04603"
